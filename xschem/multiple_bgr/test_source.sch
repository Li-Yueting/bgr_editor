v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {multiple_bgr/bgr_final_0.sym} 1910 800 0 0 {name=x1}
C {multiple_bgr/bgr_gen8_0.sym} 2330 800 0 0 {name=x2}
