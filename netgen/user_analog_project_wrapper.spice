* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd2 vdda1 vdda2 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10]
+ wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16]
+ wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20] wbs_adr_i[21]
+ wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26] wbs_adr_i[27]
+ wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31] wbs_adr_i[3]
+ wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i
+ wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i vssa1 vccd1
X0 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=8.2639e+13p pd=5.2584e+08u as=7.41675e+14p ps=5.29422e+09u w=6.45e+06u l=2e+06u
X1 a_512652_505382# a_519388_502928# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X2 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X3 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X4 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=8.2639e+13p ps=5.2584e+08u w=6.45e+06u l=2e+06u
X5 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X6 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X7 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=7.39355e+13p ps=5.3426e+08u w=6.45e+06u l=2e+06u
X8 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X9 a_511496_316775# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_21/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X10 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X11 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X12 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.595e+13p ps=1.1638e+08u w=5e+06u l=1e+06u
X13 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X14 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X15 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=7.482e+12p pd=5.392e+07u as=0p ps=0u w=6.45e+06u l=2e+06u
X16 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.595e+13p ps=1.1638e+08u w=5e+06u l=1e+06u
X17 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=7.8898e+13p ps=4.8148e+08u w=3.87e+07u l=2e+06u
X18 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X19 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X20 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X21 a_504707_433422# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_3/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X22 a_511496_343921# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_18/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X23 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X24 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X25 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X26 vccd1 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X27 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X28 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=8.3288e+13p ps=5.8426e+08u w=5e+06u l=1e+06u
X29 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X30 vccd1 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X31 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.595e+13p pd=1.1638e+08u as=8.9279e+14p ps=5.17414e+09u w=5e+06u l=1e+06u
X32 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X33 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X34 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X35 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.595e+13p pd=1.1638e+08u as=0p ps=0u w=5e+06u l=1e+06u
X36 vssa1 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.624e+13p ps=1.1606e+08u w=2e+06u l=2e+06u
X37 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=7.39355e+13p pd=5.3426e+08u as=0p ps=0u w=6.45e+06u l=2e+06u
X38 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X39 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X40 vccd1 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X41 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X42 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X43 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X44 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X45 a_512227_437244# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_13/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X46 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X47 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X48 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X49 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X50 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X51 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.595e+13p pd=1.1638e+08u as=0p ps=0u w=5e+06u l=1e+06u
X52 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X53 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X54 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.16e+13p pd=8.58e+07u as=1.276e+13p ps=9.438e+07u w=4e+06u l=2e+06u
X55 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X56 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X57 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X58 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X59 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X60 a_512652_507018# a_519388_504564# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X61 a_515256_324027# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_11/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X62 a_519747_404512# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_9/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X63 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.595e+13p ps=1.1638e+08u w=5e+06u l=1e+06u
X64 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X65 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X66 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X67 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X68 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X69 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X70 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X71 a_512652_502110# a_519388_506200# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X72 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X73 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.595e+13p ps=1.1638e+08u w=5e+06u l=1e+06u
X74 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X75 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=5.79855e+13p ps=4.1788e+08u w=6.45e+06u l=2e+06u
X76 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=5.79855e+13p pd=4.1788e+08u as=0p ps=0u w=6.45e+06u l=2e+06u
X77 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=1.595e+13p pd=1.1638e+08u as=0p ps=0u w=5e+06u l=1e+06u
X78 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X79 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X80 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X81 a_530296_328045# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_0/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X82 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X83 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X84 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X85 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X86 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X87 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X88 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X89 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X90 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X91 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X92 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X93 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X94 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X95 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X96 a_500947_436166# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_2/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X97 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X98 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X99 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.30935e+13p ps=9.436e+07u w=6.45e+06u l=2e+06u
X100 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X101 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X102 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X103 a_511496_349422# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_10/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X104 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X105 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X106 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X107 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X108 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X109 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X110 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X111 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X112 gpio_analog[5] a_519388_499656# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X113 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X114 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X115 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X116 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X117 a_507736_355485# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_24/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X118 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X119 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X120 a_523507_403826# vssa1 vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X121 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X122 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2e+06u l=2e+06u
X123 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X124 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X125 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X126 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X127 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X128 a_512227_434500# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_14/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X129 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X130 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.16e+12p pd=9.16e+06u as=0p ps=0u w=2e+06u l=2e+06u
X131 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X132 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X133 a_523507_406570# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_4/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X134 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X135 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.595e+13p pd=1.1638e+08u as=0p ps=0u w=5e+06u l=1e+06u
X136 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X137 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X138 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=1.1223e+13p pd=7.914e+07u as=0p ps=0u w=1.29e+07u l=2e+06u
X139 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X140 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=2e+06u
X141 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X142 a_515256_321283# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_13/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X143 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X144 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X145 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X146 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X147 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X148 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X149 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X150 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X151 a_530296_322557# vssa1 vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X152 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=1.30935e+13p pd=9.436e+07u as=0p ps=0u w=6.45e+06u l=2e+06u
X153 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X154 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X155 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X156 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X157 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X158 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X159 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X160 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X161 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X162 a_530296_325301# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_1/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X163 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X164 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X165 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X166 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X167 a_500947_433422# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_3/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X168 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X169 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X170 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X171 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X172 a_515256_355485# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_9/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X173 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=7.482e+12p pd=5.392e+07u as=0p ps=0u w=6.45e+06u l=2e+06u
X174 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X175 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X176 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X177 vccd1 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=7.482e+12p ps=5.392e+07u w=6.45e+06u l=2e+06u
X178 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X179 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X180 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X181 a_512227_431756# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_10/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X182 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X183 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X184 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X185 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X186 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X187 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X188 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=7.83e+12p pd=5.574e+07u as=0p ps=0u w=9e+06u l=2e+06u
X189 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X190 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X191 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X192 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X193 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X194 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X195 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X196 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X197 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X198 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X199 a_515987_439498# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_19/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X200 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X201 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X202 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X203 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.276e+13p pd=9.438e+07u as=0p ps=0u w=4e+06u l=2e+06u
X204 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X205 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X206 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X207 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X208 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X209 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X210 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X211 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X212 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X213 a_512652_500474# a_519388_502928# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X214 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X215 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X216 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X217 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.566e+13p pd=1.1032e+08u as=0p ps=0u w=9e+06u l=2e+06u
X218 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X219 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X220 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X221 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X222 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X223 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X224 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X225 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X226 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X227 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X228 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X229 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X230 a_507736_333141# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_25/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X231 vssa1 gpio_analog[4] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.16e+13p ps=8.58e+07u w=4e+06u l=2e+06u
X232 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X233 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X234 a_512652_501292# a_519388_498838# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X235 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X236 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X237 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X238 a_530296_317069# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_2/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X239 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X240 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X241 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X242 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X243 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X244 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X245 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X246 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X247 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X248 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X249 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X250 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X251 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X252 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X253 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X254 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X255 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X256 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X257 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=6.7338e+13p ps=4.6788e+08u w=3.87e+07u l=2e+06u
X258 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X259 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X260 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X261 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X262 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X263 vssa1 vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=2.15e+07u
X264 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X265 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X266 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X267 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X268 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X269 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X270 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X271 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X272 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X273 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X274 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X275 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X276 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X277 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X278 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X279 vssa1 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/VbEnd vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=2.15e+07u
X280 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X281 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X282 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X283 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X284 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=5.8e+12p pd=4.29e+07u as=0p ps=0u w=4e+06u l=2e+06u
X285 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X286 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X287 a_515987_436754# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_20/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X288 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X289 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X290 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X291 a_512227_405492# bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X292 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X293 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X294 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X295 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X296 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X297 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X298 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X299 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X300 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X301 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X302 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X303 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X304 vccd1 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X305 a_515987_442242# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_18/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X306 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=1.1223e+13p pd=7.914e+07u as=0p ps=0u w=1.29e+07u l=2e+06u
X307 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X308 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X309 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X310 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X311 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X312 gpio_analog[5] bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X313 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X314 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X315 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X316 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X317 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X318 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X319 a_497187_419016# bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X320 gpio_analog[5] bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X321 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X322 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X323 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X324 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X325 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X326 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X327 a_512652_502110# a_519388_499656# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X328 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X329 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X330 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X331 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X332 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X333 a_527267_431560# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_27/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X334 vssa1 vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=1.662e+07u
X335 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X336 a_530296_319813# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_2/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X337 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X338 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X339 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X340 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[4] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X341 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X342 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X343 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X344 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X345 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X346 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X347 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X348 a_511496_319519# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_21/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X349 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X350 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X351 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X352 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X353 a_503976_326967# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_27/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X354 a_508467_434023# vssa1 vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X355 a_519747_404512# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_11/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X356 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X357 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X358 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X359 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[2] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X360 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X361 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X362 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X363 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X364 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X365 a_515987_431266# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_19/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X366 a_526536_317069# gpio_analog[1] vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X367 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X368 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X369 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X370 a_515256_315795# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_12/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X371 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X372 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X373 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X374 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X375 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X376 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X377 a_515987_434010# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_20/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X378 a_508467_437342# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_10/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X379 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X380 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X381 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X382 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X383 vccd1 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X384 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X385 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X386 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X387 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X388 a_511496_352741# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_16/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X389 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X390 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X391 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X392 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X393 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X394 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X395 vccd1 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=7.482e+12p ps=5.392e+07u w=6.45e+06u l=2e+06u
X396 vccd1 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X397 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X398 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X399 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X400 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X401 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X402 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X403 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X404 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X405 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X406 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X407 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X408 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X409 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X410 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X411 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X412 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X413 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X414 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X415 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X416 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X417 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X418 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X419 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X420 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X421 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X422 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X423 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X424 a_503976_354799# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_10/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X425 gpio_analog[5] bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X426 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X427 a_512227_439988# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_7/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X428 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X429 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X430 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X431 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X432 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X433 a_511496_322263# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_19/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X434 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X435 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X436 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X437 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X438 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X439 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X440 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X441 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X442 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X443 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X444 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X445 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=5.8e+12p pd=4.29e+07u as=0p ps=0u w=4e+06u l=2e+06u
X446 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X447 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X448 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X449 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X450 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X451 a_527267_403728# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_9/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X452 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X453 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X454 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X455 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X456 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X457 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X458 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X459 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X460 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X461 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X462 vssa1 gpio_analog[2] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X463 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X464 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X465 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X466 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X467 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X468 vssa1 gpio_analog[2] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X469 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X470 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X471 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X472 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X473 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X474 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X475 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[2] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X476 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X477 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X478 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X479 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X480 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/VbgEnd a_519388_506200# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X481 a_526536_322557# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_3/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X482 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X483 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X484 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X485 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X486 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X487 a_504707_436166# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_7/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X488 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X489 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X490 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X491 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X492 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X493 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X494 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X495 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X496 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X497 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X498 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X499 a_497187_433422# bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X500 a_504707_438910# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_6/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X501 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X502 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X503 vccd1 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X504 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X505 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X506 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X507 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X508 vccd1 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X509 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X510 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X511 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X512 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X513 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X514 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X515 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X516 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X517 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X518 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X519 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X520 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X521 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X522 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X523 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X524 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X525 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X526 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X527 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X528 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X529 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X530 a_519747_435983# vssa1 vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X531 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X532 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X533 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X534 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X535 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X536 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X537 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X538 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X539 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X540 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X541 a_512227_429012# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_16/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X542 a_500947_403826# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_4/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X543 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X544 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X545 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X546 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X547 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X548 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X549 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X550 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X551 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X552 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X553 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X554 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X555 a_511496_355485# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_9/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X556 vccd1 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X557 a_500947_406570# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_4/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X558 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X559 vssa1 vssa1 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2e+06u l=2e+06u
X560 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X561 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X562 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X563 a_519747_439302# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_23/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X564 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X565 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X566 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X567 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X568 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X569 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X570 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X571 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X572 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X573 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X574 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X575 a_504707_433422# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_7/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X576 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X577 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X578 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X579 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X580 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X581 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=9e+06u l=2e+06u
X582 a_527267_434304# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_27/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X583 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X584 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X585 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X586 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X587 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X588 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X589 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X590 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X591 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X592 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X593 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X594 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X595 gpio_analog[5] bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X596 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X597 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X598 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X599 gpio_analog[5] bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X600 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X601 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X602 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X603 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X604 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X605 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X606 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X607 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X608 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X609 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X610 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X611 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X612 a_527267_406472# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_11/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X613 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X614 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X615 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X616 a_508467_404218# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_11/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X617 vccd1 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X618 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X619 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X620 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X621 vccd1 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X622 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X623 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X624 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X625 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X626 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X627 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X628 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X629 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X630 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X631 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X632 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X633 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X634 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X635 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X636 vccd1 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X637 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X638 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X639 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X640 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X641 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X642 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X643 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X644 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X645 vccd1 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X646 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X647 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X648 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X649 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X650 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X651 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X652 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X653 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X654 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X655 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X656 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X657 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X658 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X659 a_526536_319813# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_5/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X660 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X661 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X662 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X663 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X664 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X665 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X666 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X667 a_507736_327653# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_27/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X668 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X669 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X670 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X671 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X672 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X673 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X674 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X675 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X676 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X677 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X678 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X679 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X680 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X681 a_511496_331194# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_27/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X682 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X683 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X684 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X685 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X686 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X687 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X688 a_507736_355485# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_23/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X689 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X690 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X691 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X692 a_511496_346665# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_16/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X693 a_511496_325007# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_19/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X694 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X695 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X696 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X697 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X698 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X699 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X700 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X701 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X702 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X703 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X704 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X705 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X706 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X707 a_507736_352741# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_23/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X708 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X709 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X710 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X711 a_515256_318539# bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X712 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X713 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X714 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X715 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X716 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X717 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X718 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X719 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X720 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X721 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X722 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X723 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X724 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X725 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X726 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X727 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X728 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X729 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X730 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X731 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X732 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X733 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X734 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X735 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X736 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X737 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X738 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X739 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X740 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X741 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X742 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X743 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X744 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X745 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X746 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X747 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X748 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X749 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X750 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X751 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X752 a_511496_343921# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_17/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X753 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X754 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X755 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X756 a_500216_354799# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_23/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X757 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X758 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X759 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X760 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X761 a_515256_352741# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_10/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X762 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X763 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X764 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X765 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X766 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X767 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X768 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X769 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X770 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X771 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X772 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X773 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X774 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X775 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X776 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X777 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X778 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X779 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X780 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X781 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X782 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X783 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X784 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X785 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X786 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X787 a_519747_435983# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_23/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X788 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X789 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X790 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X791 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X792 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2e+06u l=2e+06u
X793 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X794 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X795 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X796 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X797 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X798 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/VbgEnd vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=1.662e+07u
X799 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X800 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X801 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X802 a_530296_328045# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_0/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X803 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X804 vssa1 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2e+06u l=2e+06u
X805 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X806 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X807 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X808 a_519016_317069# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_0/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X809 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X810 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X811 vccd1 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X812 a_519747_439302# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_20/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X813 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X814 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X815 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X816 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X817 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X818 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X819 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X820 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X821 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X822 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X823 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X824 a_512227_405492# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_0/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X825 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X826 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X827 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X828 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X829 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X830 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X831 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X832 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X833 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X834 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X835 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X836 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X837 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X838 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X839 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X840 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X841 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X842 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X843 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X844 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X845 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X846 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X847 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X848 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X849 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X850 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X851 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X852 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X853 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X854 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X855 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X856 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X857 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X858 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X859 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X860 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X861 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X862 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X863 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X864 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X865 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X866 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X867 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X868 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X869 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X870 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X871 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X872 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X873 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X874 a_530296_322557# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_3/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X875 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X876 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X877 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[4] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X878 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X879 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X880 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X881 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X882 vccd1 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X883 a_530296_325301# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_1/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X884 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X885 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X886 vssa1 gpio_analog[4] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X887 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X888 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X889 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X890 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X891 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X892 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X893 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X894 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X895 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X896 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X897 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X898 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X899 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X900 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X901 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X902 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=2e+06u
X903 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X904 a_515256_355485# bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X905 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X906 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X907 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X908 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X909 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X910 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X911 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=9e+06u l=2e+06u
X912 vssa1 vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X913 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X914 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X915 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X916 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X917 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X918 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X919 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X920 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X921 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X922 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X923 vssa1 gpio_analog[6] bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2.7e+07u l=2e+06u
X924 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X925 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X926 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X927 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X928 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X929 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X930 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X931 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X932 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X933 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X934 a_512652_505382# bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/VbEnd vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X935 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X936 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X937 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X938 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X939 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X940 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X941 a_512227_439988# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_12/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X942 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X943 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X944 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X945 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X946 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X947 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X948 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X949 a_511496_316775# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_11/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X950 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X951 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X952 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X953 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X954 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X955 a_507736_330397# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_25/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X956 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X957 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X958 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X959 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X960 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X961 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X962 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X963 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X964 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X965 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X966 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X967 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X968 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X969 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X970 vssa1 vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=2.15e+07u
X971 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X972 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X973 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X974 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X975 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X976 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X977 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X978 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X979 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X980 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X981 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X982 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X983 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X984 a_526536_322557# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_5/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X985 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X986 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X987 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X988 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X989 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X990 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X991 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X992 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X993 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X994 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X995 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X996 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X997 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X998 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X999 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1000 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1001 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1002 a_515256_324027# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_11/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1003 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1004 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1005 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1006 a_515987_442242# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_16/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1007 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1008 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1009 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1010 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1011 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1012 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1013 a_497187_419016# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_1/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1014 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1015 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1016 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1017 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1018 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1019 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1020 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1021 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1022 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1023 vccd1 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1024 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1025 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1026 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1027 a_527267_431560# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_18/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1028 a_500947_436166# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_1/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1029 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1030 vccd1 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1031 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1032 a_530296_319813# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_2/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1033 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1034 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1035 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1036 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1037 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1038 a_511496_349422# vssa1 vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X1039 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1040 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1041 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1042 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1043 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1044 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1045 a_512227_429012# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_16/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1046 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1047 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1048 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1049 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1050 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1051 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1052 a_503976_326967# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_25/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1053 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1054 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1055 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1056 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1057 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1058 vssa1 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__pnp_05v5 area=0p
X1059 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1060 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1061 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1062 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1063 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1064 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1065 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1066 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1067 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1068 a_515256_315795# bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1069 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1070 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1071 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1072 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1073 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1074 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=2.2446e+13p pd=1.5828e+08u as=0p ps=0u w=1.29e+07u l=2e+06u
X1075 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1076 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1077 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1078 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1079 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1080 a_515256_321283# bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1081 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1082 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1083 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1084 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1085 vccd1 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1086 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1087 vssa1 gpio_analog[2] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1088 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1089 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1090 a_511496_352741# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_15/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1091 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1092 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1093 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1094 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1095 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=9e+06u l=2e+06u
X1096 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1097 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1098 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1099 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1100 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1101 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1102 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1103 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1104 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1105 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1106 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1107 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1108 a_504707_404022# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_9/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1109 a_500947_433422# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_2/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1110 vssa1 vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X1111 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1112 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1113 a_503976_354799# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_24/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1114 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1115 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1116 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1117 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1118 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1119 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1120 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1121 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1122 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1123 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1124 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1125 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1126 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1127 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1128 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1129 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1130 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1131 a_511496_322263# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_11/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1132 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1133 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1134 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1135 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1136 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1137 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1138 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1139 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1140 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1141 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1142 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1143 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1144 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1145 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1146 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1147 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1148 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1149 a_527267_403728# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_25/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1150 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1151 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1152 a_515987_439498# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_19/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1153 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1154 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1155 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1156 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1157 a_526536_319813# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_1/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1158 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1159 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1160 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1161 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1162 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1163 a_507736_327653# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_27/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1164 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1165 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1166 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1167 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1168 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1169 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1170 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1171 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1172 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1173 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1174 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1175 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1176 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1177 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1178 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1179 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1180 a_512227_437244# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_10/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1181 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1182 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1183 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1184 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1185 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1186 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1187 a_512652_501292# a_519388_504564# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X1188 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1189 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1190 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1191 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1192 a_530296_317069# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_0/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1193 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1194 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1195 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1196 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1197 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1198 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1199 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1200 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1201 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1202 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1203 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1204 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1205 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1206 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1207 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1208 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1209 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1210 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1211 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1212 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1213 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1214 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1215 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1216 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1217 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1218 a_507736_352741# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_23/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1219 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1220 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1221 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1222 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1223 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1224 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1225 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1226 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1227 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1228 a_515987_436754# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_20/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1229 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1230 a_519016_317069# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_1/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1231 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1232 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1233 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1234 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1235 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1236 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1237 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1238 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1239 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1240 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1241 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1242 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1243 a_500947_403826# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_4/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1244 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1245 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1246 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1247 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1248 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1249 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1250 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1251 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1252 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1253 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/vg bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=9e+06u l=2e+06u
X1254 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1255 a_523507_403826# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_5/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1256 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1257 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1258 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1259 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1260 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1261 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1262 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1263 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1264 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1265 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1266 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1267 a_500947_406570# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_5/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1268 a_512227_434500# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_13/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1269 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1270 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1271 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1272 a_523507_406570# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_25/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1273 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1274 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1275 vccd1 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1276 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X1277 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1278 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1279 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=9e+06u l=2e+06u
X1280 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1281 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1282 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1283 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1284 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1285 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1286 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1287 a_511496_319519# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_13/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1288 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1289 a_500216_354799# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_18/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1290 vssa1 vssa1 vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=1.662e+07u
X1291 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1292 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1293 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1294 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1295 a_508467_434023# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_14/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X1296 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1297 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1298 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1299 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1300 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1301 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1302 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1303 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1304 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1305 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1306 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1307 a_515987_431266# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_16/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1308 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1309 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1310 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter a_519388_498838# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X1311 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1312 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1313 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1314 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1315 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1316 a_515987_434010# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_19/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1317 a_508467_437342# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_10/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1318 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1319 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1320 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1321 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1322 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1323 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1324 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1325 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1326 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1327 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1328 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1329 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1330 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1331 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1332 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1333 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1334 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1335 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1336 a_512227_431756# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_12/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1337 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1338 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1339 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1340 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1341 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1342 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1343 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1344 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1345 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1346 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1347 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1348 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1349 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1350 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1351 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1352 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1353 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1354 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1355 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1356 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1357 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1358 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1359 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1360 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1361 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1362 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1363 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1364 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1365 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1366 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1367 a_507736_333141# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_25/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1368 vccd1 vccd1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X1369 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1370 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1371 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1372 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1373 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1374 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1375 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1376 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1377 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1378 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1379 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1380 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1381 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1382 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1383 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1384 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1385 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1386 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1387 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1388 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[4] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1389 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1390 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1391 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1392 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1393 vssa1 gpio_analog[4] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1394 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1395 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1396 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1397 vssa1 gpio_analog[4] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1398 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/Vb a_519388_498020# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X1399 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1400 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1401 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1402 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1403 a_515256_318539# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_12/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1404 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1405 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1406 vccd1 vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1407 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1408 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1409 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1410 a_512652_500474# a_519388_498020# vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X1411 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1412 a_512652_507018# bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/VaEnd vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=3.152e+07u
X1413 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1414 a_497187_433422# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_0/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1415 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1416 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1417 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1418 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1419 vccd1 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1420 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1421 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1422 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1423 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1424 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1425 vccd1 vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1426 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1427 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1428 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1429 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1430 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1431 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1432 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1433 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1434 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1435 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1436 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1437 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1438 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1439 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1440 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1441 vssa1 bandgaptop_flat_io_0/bandgaptop_flat_0/bandgapcorev3_0/VaEnd vssa1 sky130_fd_pr__res_xhigh_po_2p85 l=2.15e+07u
X1442 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1443 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1444 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1445 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1446 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1447 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1448 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1449 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1450 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1451 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1452 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1453 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1454 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1455 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1456 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1457 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1458 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1459 a_515256_352741# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_10/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1460 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1461 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1462 gpio_analog[3] bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1463 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1464 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1465 a_511496_355485# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_15/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1466 vccd1 vccd1 gpio_analog[2] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1467 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1468 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1469 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1470 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[4] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1471 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1472 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1473 a_526536_317069# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_2/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1474 a_507736_330397# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_19/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1475 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1476 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[4] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1477 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1478 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1479 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1480 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1481 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1482 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1483 gpio_analog[5] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1484 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1485 gpio_analog[4] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1486 gpio_analog[3] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1487 a_527267_434304# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_6/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1488 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1489 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[2] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1490 gpio_analog[2] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1491 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1492 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1493 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1494 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[2] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1495 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1496 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1497 vccd1 vccd1 gpio_analog[4] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1498 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1499 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1500 vssa1 vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1501 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1502 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1503 vccd1 vccd1 gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1504 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1505 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1506 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1507 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1508 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1509 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1510 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1511 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1512 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1513 vssa1 vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1514 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1515 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1516 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1517 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1518 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1519 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1520 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1521 gpio_analog[4] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1522 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vq vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=9e+06u l=2e+06u
X1523 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1524 vccd1 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1525 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1526 a_527267_406472# gpio_analog[3] vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1527 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1528 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1529 a_508467_404218# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_11/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1530 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1531 vccd1 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1532 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1533 gpio_analog[3] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1534 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1535 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1536 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1537 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1538 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1539 gpio_analog[2] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1540 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1541 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1542 gpio_analog[6] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1543 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1544 vssa1 vssa1 gpio_analog[1] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1545 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1546 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1547 vccd1 vccd1 gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1548 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1549 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1550 vssa1 vssa1 gpio_analog[6] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1551 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1552 vssa1 vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1553 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1554 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1555 vccd1 vccd1 gpio_analog[6] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1556 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1557 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1558 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1559 vccd1 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate gpio_analog[5] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.87e+07u l=2e+06u
X1560 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1561 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1562 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1563 gpio_analog[6] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1564 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1565 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1566 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1567 gpio_analog[1] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1568 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1569 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1570 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1571 vssa1 vssa1 bgr_gen7_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1572 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1573 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout gpio_analog[3] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1574 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1575 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1576 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1577 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1578 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1579 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin bgr_top_0/sky130_asc_nfet_01v8_lvt_1_1/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1580 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1581 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1582 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1583 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1584 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1585 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1586 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1587 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1588 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1589 a_511496_331194# vssa1 vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=1.075e+07u
X1590 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1591 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1592 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1593 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1594 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1595 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1596 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1597 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1598 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1599 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1600 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/DRAIN vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1601 a_504707_436166# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_7/Rin vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1602 a_511496_346665# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_17/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1603 a_511496_325007# bgr_gen7_0/sky130_asc_res_xhigh_po_2p85_1_19/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1604 vssa1 gpio_analog[2] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1605 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1606 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1607 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1608 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1609 bandgaptop_flat_io_0/bandgaptop_flat_0/amplifier_0/Vx bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.29e+07u l=2e+06u
X1610 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1611 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1612 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1613 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1614 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1615 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1616 a_504707_438910# bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
X1617 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1618 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1619 bgr_top_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1620 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[2] vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1621 vccd1 vccd1 gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1622 gpio_analog[1] bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1623 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1624 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1625 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1626 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1627 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1628 gpio_analog[5] vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1629 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1630 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1631 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1632 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1633 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1634 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1635 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1636 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1637 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1638 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout gpio_analog[1] vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1639 bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1640 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1641 bandgaptop_flat_io_0/bandgaptop_flat_0/currentmirror_0/Vgate vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1642 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1643 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1644 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1645 vssa1 vssa1 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[7|4]/Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
X1646 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1647 gpio_analog[1] vccd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1648 vssa1 vssa1 gpio_analog[5] vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X1649 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1650 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1651 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin bgr_gen7_0/sky130_asc_nfet_01v8_lvt_1_0/DRAIN vssa1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=4e+06u l=2e+06u
X1652 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1653 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1654 bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1655 vssa1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1656 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1657 vssa1 vssa1 bgr_top_0/sky130_asc_pnp_05v5_W3p40L3p40_7_0/Emitter sky130_fd_pr__pnp_05v5 area=0p
X1658 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout vccd1 sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1659 vccd1 bgr_gen7_0/sky130_asc_cap_mim_m3_1_0/Cout bgr_gen7_0/sky130_asc_cap_mim_m3_1_5/Cin vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1660 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1661 vssa1 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__pnp_05v5 area=0p
X1662 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1663 vssa1 bgr_top_0/sky130_asc_cap_mim_m3_1_0/Cin sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
X1664 vccd1 bgr_top_0/sky130_asc_cap_mim_m3_1_5/Cout bgr_top_0/sky130_asc_nfet_01v8_lvt_9_1/GATE vccd1 sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=6.45e+06u l=2e+06u
X1665 bandgaptop_flat_io_0/sky130_fd_pr__rf_pnp_05v5_W3p40L3p40_0[4|2]/Emitter vssa1 sky130_fd_pr__cap_mim_m3_2 l=2e+06u w=2e+06u
X1666 a_504707_404022# bgr_top_0/sky130_asc_res_xhigh_po_2p85_1_9/Rout vssa1 sky130_fd_pr__res_xhigh_po w=2.85e+06u l=7.88e+06u
.ends
